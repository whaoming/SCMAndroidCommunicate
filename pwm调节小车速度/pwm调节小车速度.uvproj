# Keil uVision project pwm调节小车速度.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: pwm调节小车速度 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c HJ-4WD_PWM.h
